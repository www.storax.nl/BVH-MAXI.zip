Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 5ff2f621-6bd7-45b8-9313-120eeea33703.ifc
Time: 2026-08-11T12:16:39
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, uitneembaar Storax - BVH-MAXI 110, 1000x1000mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAALI89bYDAAAAR-sCAAV2SgAA2FMBAFJfAQAi7AIA8ewCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAALI89bYDAAAAR-sCAAV2SgAA2FMBAFJfAQAi7AIA8ewCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 52 kg/st; STABU2: 43.31.10; dagmaatlengte: 1000 mm; lengte: 1152 mm; NAA.K.T: samengesteld_product_kozijn; Rc-waarde: 0 m²·k/w; breedte: 1152 mm; serie: BVH-MAXI; afsluitbaar: True; hoogte: 125 mm; merk: Storax; breuklast: B125; type: 110; dagmaatbreedte: 1000 mm; omranding: staal; luik: staal
