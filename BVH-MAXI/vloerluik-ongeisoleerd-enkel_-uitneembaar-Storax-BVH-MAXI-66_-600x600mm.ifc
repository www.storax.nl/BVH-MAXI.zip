Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 83e9285e-46db-4f11-adb2-6ec44ead53f5.ifc
Time: 2026-08-11T12:15:21
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, uitneembaar Storax - BVH-MAXI 66, 600x600mm
In: Bouwlaag
Material: staal
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAALJx87YDAAAAR-sCAAV2SgAA2FMBAFJfAQAi7AIAvOoCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAALJx87YDAAAAR-sCAAV2SgAA2FMBAFJfAQAi7AIAvOoCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 28 kg/st; STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 752 mm; NAA.K.T: samengesteld_product_kozijn; Rc-waarde: 0 m²·k/w; breedte: 752 mm; serie: BVH-MAXI; afsluitbaar: True; hoogte: 125 mm; merk: Storax; breuklast: B125; type: 66; dagmaatbreedte: 600 mm; omranding: staal; luik: staal
